SRC_URI += "file://user_2018-04-30-10-48-00.cfg \
            file://user_2018-04-30-12-59-00.cfg \
            file://0001-char-xilinx_devcfg-Fix-regression.patch \
            file://user_2020-02-15-17-40-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

