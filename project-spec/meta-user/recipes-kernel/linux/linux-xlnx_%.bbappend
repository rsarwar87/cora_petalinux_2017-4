SRC_URI += "file://user_2018-04-30-10-48-00.cfg \
            file://user_2018-04-30-12-59-00.cfg \
            file://0001-char-xilinx_devcfg-Fix-regression.patch \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

